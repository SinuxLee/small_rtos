# Keil uVision project test.uvproj, settings and files
target Target 1 (MCS-51)
  device: 89C52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(24000000)
  output: test
  c flags: Optimize=7 SizeSpeed=1
  group os
    ../os/: Os_core.c
    ../OS/: Os_q.c Os_sem.c
  group user
    ./: ext1.c
  group Target CPU
    ../keilc51/: Os_cpu_c.c Os_cpu_a.asm
