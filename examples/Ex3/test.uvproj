# Keil uVision project test.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: test +hex
  c flags: Optimize=8 SizeSpeed=1
  group os
    ../../src/core/: os_core.c
  group user
    ./: display.c main.c
  group C51
    ../../src/c51/: os_cpu_a.asm os_cpu_c.c
