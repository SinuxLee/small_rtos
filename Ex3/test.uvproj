# Keil uVision project test.uvproj, settings and files
target Target 1 (MCS-51)
  device: 89C52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(24000000)
  output: test
  c flags: Optimize=8 SizeSpeed=1
  group os
    ../os/: Os_core.c
  group user
    ./: display.c Ext3.c
  group Target CPU
    ../keilc51/: Os_cpu_c.c
    ../KEILC51/: Os_cpu_a.asm
